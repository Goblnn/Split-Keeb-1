File: fourier-left/fourier-left-bottom.kicad_pcb (KiCad board)
At the start: 2 copper layers, 136.6 x 92.2 mm, 9 parts

Commit message: adad
Other:
- net class Default removed
